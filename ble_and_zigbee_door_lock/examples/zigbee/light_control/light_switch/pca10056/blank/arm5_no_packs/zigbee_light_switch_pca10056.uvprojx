# Keil uVision project zigbee_light_switch_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET ENABLE_FEM FLOAT_ABI_HARD KEIL NRF52840_XXAA SWI_DISABLE0 ZB_ED_ROLE ZB_TRACE_LEVEL=0 ZB_TRACE_MASK=0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features;..\..\..\..\..\..\..\external\zboss\include;..\..\..\..\..\..\..\external\zboss\include\ha;..\..\..\..\..\..\..\external\zboss\include\osif;..\..\..\..\..\..\..\external\zboss\include\zcl;..\..\..\..\..\..\..\external\zboss\osif;..\..\..\..\..\..\..\external\zboss\zb_error;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\fifo
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DENABLE_FEM,-DFLOAT_ABI_HARD,-DKEIL,-DNRF52840_XXAA,-DSWI_DISABLE0,-DZB_ED_ROLE,-DZB_TRACE_LEVEL=0,-DZB_TRACE_MASK=0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features;..\..\..\..\..\..\..\external\zboss\include;..\..\..\..\..\..\..\external\zboss\include\ha;..\..\..\..\..\..\..\external\zboss\include\osif;..\..\..\..\..\..\..\external\zboss\include\zcl;..\..\..\..\..\..\..\external\zboss\osif;..\..\..\..\..\..\..\external\zboss\zb_error;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c wl_door_lock_config.h wl_door_lock_uart_cmd.h
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group Zigbee
    ../../../../../../../external/zboss/lib/keil/: libzboss.ed.lib nrf_radio_driver.lib
    ../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_ota.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
